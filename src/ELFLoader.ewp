# IAR project ELFLoader.ewp, settings and files
configuration S75sw40 (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG; NEWSGOLD; USE_LL_INIT; USE_STATIC_MEMORY; __PNG_SWI_LIB_
  ICCARM.CCIncludePath2: $PROJ_DIR$
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: NEWSGOLD
  XLINK.XclFile: S75sw40.xcl
configuration CX70sw56 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  XLINK.XclFile: CX70sw56.xcl
configuration EL71sw41 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; ELKA; NEWSGOLD; USE_LL_INIT; USE_STATIC_MEMORY
  AARM.ADefines: NEWSGOLD; ELKA
  XLINK.XclFile: EL71sw41.xcl
configuration S75sw47 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; NEWSGOLD; USE_LL_INIT; USE_STATIC_MEMORY
  XLINK.XclFile: S75sw47.xcl
configuration SL75sw47 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; NEWSGOLD; USE_LL_INIT; USE_STATIC_MEMORY
  XLINK.XclFile: SL75sw47.xcl
configuration E71sw45 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; NEWSGOLD; ELKA; USE_LL_INIT; USE_STATIC_MEMORY
  AARM.ADefines: NEWSGOLD; ELKA; USE_LL_INIT; USE_STATIC_MEMORY
  XLINK.XclFile: E71sw45.xcl
configuration EL71sw45 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; ELKA; NEWSGOLD; USE_LL_INIT; USE_STATIC_MEMORY
  AARM.ADefines: NEWSGOLD; ELKA; USE_LL_INIT; USE_STATIC_MEMORY
  XLINK.XclFile: EL71sw45.xcl
configuration C81sw51 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; NEWSGOLD; USE_LL_INIT; USE_STATIC_MEMORY
  AARM.ADefines: NEWSGOLD; USE_LL_INIT; USE_STATIC_MEMORY
  XLINK.XclFile: C81sw51.xcl
configuration S68sw47 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; NEWSGOLD; USE_LL_INIT; USE_STATIC_MEMORY
  XLINK.XclFile: S68sw47.xcl
configuration SL65sw53 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  XLINK.XclFile: SL65sw53.xcl
configuration S65sw58 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  XLINK.XclFile: S65sw58.xcl
configuration SK65sw50 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  XLINK.XclFile: SK65sw50.xcl
configuration M75sw25 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; X75
  XLINK.XclFile: M75sw25.xcl
configuration C72sw22 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  XLINK.XclFile: C72sw22.xcl
configuration CX75sw13 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; X75
  XLINK.XclFile: CX75sw13.xcl
configuration C75sw22 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; X75
  XLINK.XclFile: C75sw22.xcl
configuration CX75sw25 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; X75
  XLINK.XclFile: CX75sw25.xcl
configuration SL75sw52 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; NEWSGOLD; USE_LL_INIT; USE_STATIC_MEMORY
  XLINK.XclFile: SL75sw52.xcl
configuration CX75sw12 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; X75
  XLINK.XclFile: CX75sw12.xcl
configuration M81sw51 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; NEWSGOLD; USE_LL_INIT; USE_STATIC_MEMORY
  XLINK.XclFile: M81sw51.xcl
configuration S75sw52 (ARM)
  as the first configuration, except:
  AARM.ADefines: NEWSGOLD; USE_LL_INIT; USE_STATIC_MEMORY
  XLINK.XclFile: S75sw52.xcl
configuration CF75sw23 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; X75
  XLINK.XclFile: CF75sw23.xcl
configuration C75sw24 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; X75
  XLINK.XclFile: C75sw24.xcl
configuration S68sw52 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; NEWSGOLD; USE_LL_INIT; USE_STATIC_MEMORY
  XLINK.XclFile: S68sw52.xcl
configuration CL61sw00 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; ELKA; NEWSGOLD; USE_LL_INIT; USE_STATIC_MEMORY
  AARM.ADefines: NEWSGOLD; ELKA
  XLINK.XclFile: CL61sw00.xcl
configuration CL61sw00_db128 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; ELKA; NEWSGOLD; USE_LL_INIT; USE_STATIC_MEMORY
  AARM.ADefines: NEWSGOLD; ELKA
  XLINK.XclFile: CL61sw00_db128.xcl
  group (top)
    ./: additional.c conf_loader.c config_data.c elfloader_helper.c ESI.asm EXT2.asm FSWI.asm IMB.asm png.c rets_C72sw22.asm rets_C75sw22.asm rets_C75sw24.asm rets_C81sw51.asm rets_CF75sw23.asm rets_CL61sw00.asm rets_CL61sw00_db128.asm rets_CX70sw56.asm rets_CX75sw12.asm rets_CX75sw13.asm rets_CX75sw25.asm rets_E71sw45.asm rets_EL71sw41.asm rets_EL71sw45.asm rets_M75sw25.asm rets_M81sw51.asm rets_S65sw58.asm rets_S68sw47.asm rets_S68sw52.asm rets_S75sw40.asm rets_S75sw47.asm rets_S75sw52.asm rets_SK65sw50.asm rets_SL65sw53.asm rets_SL75sw47.asm rets_SL75sw52.asm
  group loader3
    loader3/: elf.h env.c env.h dtrace.c loadelf.c loader.c loader.h loadlib.c log.c thumb.c
